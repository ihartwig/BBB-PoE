# Repository ihartwig/BBB-PoE

File README.md:

# BBB-PoE

PoE Hat for BeagleBone Black

This hat adds Power over Ethernet to the BeagleBone Black by passing the ehternet traffic through this board into the ethernet jack on BBB board. It does not include another ethernet PHY. The PoE circuits provide 12V out which is regulated to 5V for the BBB. The BBB regulates further to 3.3V. In this case my desired application needed 12V and 5V sources.

The schematic and floorplanning are complete, but I didn't finish layout since the project changed focus. If anybody wants to extend or complete this project I would consider pull requests.

## KiCad design pcb/amtdoor2v2.kicad_pcb

Parts:
C1, C5: 0.1uF
C2: 0.47uF 16V
C3, C7, C10: 0.01uF 25V
C4: 4.7uF
C6: 2.2nF 250Vac
C8: 680pF 50V
C9: 10uF 16V
C11, C13: 47uF 20V
C12: C_Small
C14: ?
D1, D2: D_Bridge
D3: D_Schottky_Small
D4, D7, D8: 1N4148WS
D5, D6: GREEN
D9, D12: 8.2V
D10, D11, D14: D_Small
D13: PDS360
IC1: AT24CS02-SSHM; SO8
J1, J2: RJ45
L1: 8.2uH
P1, P2: CONN_02X23
P3, P4: CONN_01X02
P5: CONN_01X05
Q1: Q_NPN_BCE
Q2: Q_NMOS_DGS
R1: 300K
R2: 100
R3: 2K
R4, R20: 1K
R5, R7: 220K
R6: R
R8: 10K
R9: 0.05
R10: 150
R11, R12, R13, R14: 7.5K
R15: 13
R16, R17, R19: 28K 1%
R18: 61.9K 1%
R21: 107K 1%
SB1, SB2, SB3, SB4, SB5, SB6, SB7, SB8, SB9, SB10: SolderBridge
T1: H2019FNL
T2: PA1136/7/8
U1: LTC4267CDHC
U2, U3, U4: TLP785F; DIP-4F
U5: LT1431

Connections:
+3V3: IC1.8 (VCC), P1.3, P1.4, SB3.1, SB5.1, SB7.1, SB9.1, U4.8; also elsewhere on the board
+5V: P1.5, P1.6, P5.1, R4.1
+12V: C8.2, C9.1, C11.1, C13.1, C14.1, D13.1 (K), D14.1 (K), P3.1, P5.3, R3.1, R20.1, R21.1, U3.8
/5V_PG: P5.5, SB2.1
/5V_SHDN_L: P5.4, SB1.1
/AUX_ACTIVE: D12.1 (K), R16.2
/AUX_ACTIVE_D: D12.2 (A), U2.1
/BBB_RESET_L: P1.10, SB2.2
/BBB_SCL2: IC1.6 (SCL), P1.19, U4.6; also elsewhere on the board
/BBB_SDA2: IC1.5 (SDA), P1.20, U4.5; also elsewhere on the board
/EEP_A0: IC1.1 (A0), SB3.2, SB4.1, U4.1
/EEP_A1: IC1.2 (A1), SB5.2, SB6.1, U4.2
/EEP_A2: IC1.3 (A2), SB7.2, SB8.1, U4.3
/EEP_WP: IC1.7 (WP), SB9.2, SB10.1, U4.7
/ETH_POWER1: D2.3 (AC), J1.4, J1.5
/ETH_POWER2: D2.4 (AC), J1.7, J1.8
/ETH_RDn: J2.6, T1.8 (RD-); also elsewhere on the board
/ETH_RDp: J2.3, T1.6 (RD+); also elsewhere on the board
/ETH_RXn: J1.6, T1.9 (RX-)
/ETH_RXp: J1.3, T1.11 (RX+)
/ETH_TDn: J2.2, T1.3 (TD-); also elsewhere on the board
/ETH_TDp: J2.1, T1.1 (TD+); also elsewhere on the board
/ETH_TXn: J1.2, T1.14 (TX-)
/ETH_TXp: J1.1, T1.16 (TX+)
/ITH_FB: D7.2 (A), D11.2 (A), U1.1 (ITH/RUN)
/NGATE_ITH_DRAIN: C2.1, D4.2 (A), D7.1 (K), R1.2
/PP_12V_AUX: D14.2 (A), P4.1, R16.1
/PP_ETH_N: C1.2, C2.2, C3.2, D1.2 (-), D2.2 (-), D3.2 (A), R6.2, R12.2, U1.7 (VPORTN)
/PP_ETH_P: C5.1, D4.1 (K), L1.2, Q1.3, R5.1, R7.1, T2.4 (SRC2), U1.13 (VPORTP), U2.8
/PP_ETH_P_L: C1.1, D1.1 (+), D2.1 (+), D3.1 (K), L1.1
/PP_VCC: C4.1, D10.1 (K), Q1.2, R7.2, R11.2, R13.2, U1.4 (PVCC)
/PWRGD_ISO: R17.1, SB1.2, U3.7
/PWRGD_L: U1.11 (~PWRGD), U3.2
/SIGDISA: R12.1, U1.12 (SIGDISA), U2.7
/SW_D: Q2.1, Q2.2, Q2.5, Q2.6, T2.3 (SRC1)
/SW_G: D8.2 (A), Q2.3, U1.3 (NGATE)
/SW_S: Q2.4, R8.1, R9.1
/SW_SENSE: R8.2, U1.14 (SENSE)
/VOUT_D: D13.2 (A), R15.2, T2.7 (OUT1), T2.8 (OUT1)
/VOUT_FB: C7.1, C10.1, R14.1, R20.2, U5.3 (V+)
/VOUT_FB_A: C7.2, R14.2, U2.3
/VOUT_FB_K: C12.1, U2.4, U5.1 (COLL)
/VOUT_FB_REF: C14.2, R18.2, R19.1, R21.2, U5.8 (REF)
/VOUT_RC: C8.1, R15.1
unnamed: C3.1, R1.1, R2.2
unnamed: C12.2, R18.1
unnamed: D1.3 (AC), T1.15 (TXCT)
unnamed: D1.4 (AC), T1.10 (RXCT)
unnamed: D5.2 (A), R3.2
unnamed: D6.2 (A), R4.2
unnamed: D8.1 (K), R2.1
unnamed: D9.1 (K), Q1.1, R5.2
unnamed: D10.2 (A), R10.2
unnamed: D11.1 (K), R11.1, U2.6
unnamed 78: P1.34; also elsewhere on the board
unnamed: R6.1, U1.5 (RCLASS)
unnamed: R10.1, T2.2 (FB1)
unnamed: R13.1, U3.1
unnamed 134: T1.2 (TDCT); also elsewhere on the board
unnamed 135: T1.7 (RDCT); also elsewhere on the board

Notes on the sheet:
Eth+Power
Eth to Device
TODO: change to NEC PS2911-1-K-A?
Samtec Inc SSQ-123-03-T-D
External 5V Regulator (Pololu D24V10F5)
External 12V Input
Cape EEPROM

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
Board: 2 copper layers, 54.6 x 86.4 mm, 81 parts (14 on the bottom side), 62 nets.

Other parts of the board:
P6: CONN_02X03; Pin_Header_Angled_2x03
R22: 4.7k; R_0805
R23: 4.7K; R_0805
R24: 100k; R_0805
R25: 100K; R_0805
SB11: SolderBridge; SB_0805

Their connections:
+3V3: R22.1, R23.1; also elsewhere on the board
/BBB_SCL2: R23.2; also elsewhere on the board
/BBB_SDA2: R22.2; also elsewhere on the board
/ETH_RDn: P6.6; also elsewhere on the board
/ETH_RDp: P6.5; also elsewhere on the board
/ETH_TDn: P6.2; also elsewhere on the board
/ETH_TDp: P6.1; also elsewhere on the board
unnamed 78: SB11.1; also elsewhere on the board
unnamed 134: R24.2; also elsewhere on the board
unnamed 135: R25.2; also elsewhere on the board

## Commit log

2016-03-22 add .DS_Store to gitignore for OS X
2016-03-22 add schematic and pcb floorplan
